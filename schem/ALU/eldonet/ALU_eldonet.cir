* Component: /home/training/ALU_CL/schem/ALU  Viewpoint: eldonet
.INCLUDE /home/training/ALU_CL/schem/ALU/eldonet/ALU_eldonet.spi

.OPTION NOASCII
.OPTION MODWL
.OPTION ENGNOT
.OPTION AEX

.TEMP 27

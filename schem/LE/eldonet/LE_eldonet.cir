* Component: /home/training/ALU_CL/schem/LE  Viewpoint: eldonet
.INCLUDE /home/training/ALU_CL/schem/LE/eldonet/LE_eldonet.spi

.OPTION NOASCII
.OPTION MODWL
.OPTION ENGNOT
.OPTION AEX

.TEMP 27

* Component: /home/training/ALU_CL/schem/LA_ALU  Viewpoint: eldonet
.INCLUDE /home/training/ALU_CL/schem/LA_ALU/eldonet/LA_ALU_eldonet.spi

.OPTION NOASCII
.OPTION MODWL
.OPTION ENGNOT
.OPTION AEX

.TEMP 27

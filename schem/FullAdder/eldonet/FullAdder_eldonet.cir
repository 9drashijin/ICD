* Component: /home/training/ALU_CL/schem/FullAdder  Viewpoint: eldonet
.INCLUDE /home/training/ALU_CL/schem/FullAdder/eldonet/FullAdder_eldonet.spi

.OPTION NOASCII
.OPTION MODWL
.OPTION ENGNOT
.OPTION AEX

.TEMP 27
